Commit message: lqr simulation setup complete

File: src/dip_sim/urdf/double_pendulum.urdf (robot description, URDF)
Before this commit: robot double_pendulum, 3 links, 2 joints
Joints:
- joint joint2: origin xyz=0 -0.0508 0.022 rpy=0 0 0 -> xyz=0 -0.0508 0.0129 rpy=0 0 0
